# Keil uVision project M55M1_NS.uvprojx, settings and files
target M55M1_APROMNS_2M (6220000::V6.22::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: M55M1_NS
  AfterMake: cmd.exe /C copy .\Objects\@L.axf ..\@L.FLM
  c flags: v6Lang=5 v6LangP=3
  c define: M55M1_SERIES FLASH_APROMNS_2M PAGE_SIZE_8K
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target M55M1_APROMNS_BANK1_1M (6220000::V6.22::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: M55M1_NS_BANK1_1M
  AfterMake: cmd.exe /C copy .\Objects\@L.axf ..\@L.FLM
  c flags: v6Lang=5 v6LangP=3
  c define: M55M1_SERIES FLASH_APROMNS_BANK1_1M PAGE_SIZE_8K
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 5.5.0
